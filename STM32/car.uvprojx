# Keil uVision project car.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: .\Core;.\Config;.\Libraries\CMSIS\Core\Include;.\Libraries\STM32F10x_Device\Include;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\BSP;.\Drivers
  asm define: STM32F10X_MD,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  asm include: .\Core;.\Config;.\Libraries\CMSIS\Core\Include;.\Libraries\STM32F10x_Device\Include;.\Libraries\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Core/: startup_stm32f10x_md.s
  group User
    ./User/: main.c
    ./Core/: system_stm32f10x.c
  group StdPeriph
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group BSP
    ./BSP/: bsp_gpio.c bsp_gpio.h bsp_ws2812.c bsp_ws2812.h bsp_light.c bsp_light.h
  group Drivers
    ./Drivers/: drv_usart1_hi3861.c drv_usart1_hi3861.h
